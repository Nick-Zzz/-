# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\FIRE;..\CORE;..\STM32F10x_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE;..\HARDWARE\FLASH;..\HARDWARE\SPI;..\HARDWARE\LCD
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./FIRE/: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: startup_stm32f10x_hd.s core_cm3.c
  group STM32F10x_FWLIB
    ../STM32F10x_FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_spi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../SYSTEM/usart/: usart1.c
    ../SYSTEM/sys/: sys.c
    ../HARDWARE/: uart4.c sim800c.c timer4.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/SPI/: spi.c
